Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Delta Jardinière grand modèle.IFC
Time: 2020-07-03T11:10:41
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: H M20 A2_HM 20 (6)
In: Default Storey
Name | Material
2 x H M20 A2_HM 20
4 x H M20 A2_HM 20 | Inox A2-70

# IfcBeam: MULT-JAR-002_Default
In: Default Storey
Material: PE

# IfcBuildingElementProxy: DELT-JAR-MUL-001_Default (4)
In: Default Storey
Name
DELT-JAR-MUL-001_Default | PSet_Mass_Property - Mass Measure: 156.536; Area Measure: 21.1888; Volume Measure: 0.11429
3 x DELT-JAR-MUL-001_Default
